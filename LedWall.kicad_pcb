# Repository Skrooter/LedSquare

## KiCad design LedWall.kicad_pcb

Parts:
H101, H102, H103, H104: StackingHole; MountingHole_4.3mm_M4_Pad_Via
H105, H106: ToolingHole; JLC_toolinghole
J101, J102, J103, J104: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical; LCSC C358738

Connections:
/DataIn: J101.5, J101.6; also elsewhere on the board
/DataOut: J103.5, J103.6; also elsewhere on the board
/PWR_EN: J102.5, J102.6, J104.5, J104.6; also elsewhere on the board
GND: H101.1, H102.1, H103.1, H104.1, J101.7, J101.8, J101.9, J101.10, J102.7, J102.8, J102.9, J102.10, J103.7, J103.8, J103.9, J103.10, J104.7, J104.8, J104.9, J104.10; also elsewhere on the board
VDC: J101.1, J101.2, J101.3, J101.4, J102.1, J102.2, J102.3, J102.4, J103.1, J103.2, J103.3, J103.4, J104.1, J104.2, J104.3, J104.4; also elsewhere on the board

Notes on the sheet:
Reqs: 4 pins for every power connection 2 pins for every signal connection 2 tooling holes needed for Assembly 4 stacking holes needed to be able to stack boards

Parts:
C201: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C57112
C202, C203, C204: 47u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C96123
C205, C206: 10u/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; LCSC C13585
C207: 100n/10V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
D201, D202: B340; D_SOD-123; LCSC C8598
L201: 47u; YNR6045-470M; LCSC C497841
R201, R203: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C4184
R202: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25804
R204: 7k5; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23234
TP201, TP202, TP203, TP204, TP205, TP206, TP207, TP208, TP209, TP210, TP211, TP212, TP213, TP214, TP215, TP216, TP217, TP218: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U201: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias; LCSC C9864

Connections:
+5V: C202.1, C203.1, C204.1, L201.2, R201.1, TP202.1, TP209.1, TP210.1, TP211.1, TP212.1, TP213.1; also elsewhere on the board
/PWR_EN: R202.1; also elsewhere on the board
/Power/BOOT: C201.2, U201.1 (BOOT)
/Power/EN: C207.1, R202.2, R203.1, TP204.1, U201.5 (EN)
/Power/PH: C201.1, D202.1 (K), L201.1, TP201.1, U201.8 (PH)
/Power/VDC+: C205.2, C206.2, D201.1 (K), U201.7 (VIN)
/Power/VSENSE: R201.2, R204.1, U201.4 (VSENSE)
GND: C202.2, C203.2, C204.2, C205.1, C206.1, C207.2, D202.2 (A), R203.2, R204.2, TP205.1, TP206.1, TP207.1, TP208.1, TP214.1, TP215.1, TP216.1, TP217.1, TP218.1, U201.6 (GND), U201.9 (GNDPAD); also elsewhere on the board
VDC: D201.2 (A), TP203.1; also elsewhere on the board

Notes on the sheet:
Divider gives roughly 4.5V
V_{in}: 10V-36V V_{out}: ~4.5V I_{out}max: 1A
Reqs: Vin 12-36V Enable pulled down Enable series resistor to limit current draw on enable pin Output close to 5V > 1.5A output

Parts:
C301, C302, C303, C304, C305, C306, C307, C308, C309, C310, C311, C312, C313, C314, C315, C316, C317, C318, C319, C320, C321, C322, C323, C324, C325: 100n/10V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
D301, D302, D303, D304, D305, D306, D307, D308, D309, D310, D311, D312, D313, D314, D315, D316, D317, D318, D319, D320, D321, D322, D323, D324, D325: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; LCSC C2920042
R301: 270R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22966
R302: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C23345
TP301, TP302, TP303, TP304, TP305, TP306, TP307, TP308, TP309, TP310, TP311, TP312: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded

Connections:
+5V: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, D301.1 (VDD), D302.1 (VDD), D303.1 (VDD), D304.1 (VDD), D305.1 (VDD), D306.1 (VDD), D307.1 (VDD), D308.1 (VDD), D309.1 (VDD), D310.1 (VDD), D311.1 (VDD), D312.1 (VDD), D313.1 (VDD), D314.1 (VDD), D315.1 (VDD), D316.1 (VDD), D317.1 (VDD), D318.1 (VDD), D319.1 (VDD), D320.1 (VDD), D321.1 (VDD), D322.1 (VDD), D323.1 (VDD), D324.1 (VDD), D325.1 (VDD), R301.1; also elsewhere on the board
/DataIn: R302.2, TP301.1; also elsewhere on the board
/DataOut: D325.2 (DOUT), TP306.1; also elsewhere on the board
/LEDs/DataInFiltered: D301.4 (DIN), R301.2, R302.1
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, D301.3 (VSS), D302.3 (VSS), D303.3 (VSS), D304.3 (VSS), D305.3 (VSS), D306.3 (VSS), D307.3 (VSS), D308.3 (VSS), D309.3 (VSS), D310.3 (VSS), D311.3 (VSS), D312.3 (VSS), D313.3 (VSS), D314.3 (VSS), D315.3 (VSS), D316.3 (VSS), D317.3 (VSS), D318.3 (VSS), D319.3 (VSS), D320.3 (VSS), D321.3 (VSS), D322.3 (VSS), D323.3 (VSS), D324.3 (VSS), D325.3 (VSS), TP307.1, TP308.1, TP309.1, TP310.1, TP311.1, TP312.1; also elsewhere on the board
unnamed: D301.2 (DOUT), D302.4 (DIN)
unnamed: D302.2 (DOUT), D303.4 (DIN)
unnamed: D303.2 (DOUT), D304.4 (DIN)
unnamed: D304.2 (DOUT), D305.4 (DIN)
unnamed: D305.2 (DOUT), D310.4 (DIN), TP302.1
unnamed: D306.4 (DIN), D307.2 (DOUT)
unnamed: D306.2 (DOUT), D311.4 (DIN), TP303.1
unnamed: D307.4 (DIN), D308.2 (DOUT)
unnamed: D308.4 (DIN), D309.2 (DOUT)
unnamed: D309.4 (DIN), D310.2 (DOUT)
unnamed: D311.2 (DOUT), D312.4 (DIN)
unnamed: D312.2 (DOUT), D313.4 (DIN)
unnamed: D313.2 (DOUT), D314.4 (DIN)
unnamed: D314.2 (DOUT), D315.4 (DIN)
unnamed: D315.2 (DOUT), D320.4 (DIN), TP304.1
unnamed: D316.4 (DIN), D317.2 (DOUT)
unnamed: D316.2 (DOUT), D321.4 (DIN), TP305.1
unnamed: D317.4 (DIN), D318.2 (DOUT)
unnamed: D318.4 (DIN), D319.2 (DOUT)
unnamed: D319.4 (DIN), D320.2 (DOUT)
unnamed: D321.2 (DOUT), D322.4 (DIN)
unnamed: D322.2 (DOUT), D323.4 (DIN)
unnamed: D323.2 (DOUT), D324.4 (DIN)
unnamed: D324.2 (DOUT), D325.4 (DIN)

Notes on the sheet:
Reqs: Series resistor on data in. Pull up on data in do avoid glitches when unconnected and to be able to use STM32 with open drain pin pin config
GND reference Test Points

Board: 2 copper layers, 204.0 x 204.0 mm, 107 parts (4 on the bottom side), 36 nets.

## Commit log

2022-07-20 Inital commit
2022-07-27 Updated project to kicad 6 and changed PCB
2022-08-07 Change DC/DC components and split schematic
2022-08-07 Change LED to one in JLC stock
2022-08-11 Add more vias to DC/DC
2022-08-23 Fix incorrect LCSC number for R3 and R6
    Solves issue #1
2022-10-19 Add MCAD files for easy mounting
    To be able to mount the ping pong balls
    easier I have added a 3d printable (hopefully)
    grid.
2022-10-24 Change polarity of C27
    fix #5
2022-10-24 Move 5v TP closer to DC/DC and added more TP
    fix #4
2022-10-24 Move silk to fix DRC errors
2022-10-24 Add GND testpoints
    Each other testpoint now has its own ground reference
    fix #6
2022-10-24 Add 12V testpoint
    fix #3
2022-10-29 Add some more requirements
2022-10-29 Add Mounting holes for stacking PCBs
    fix #8
2022-10-29 Change DC/DC caps to MLCC
    In an attempt to remove the large cap MLCC is tested.
2022-10-29 Add solid fill to connectors
    When I used a heat camera I saw that the hottest spot was
    the connectors, maybe a better connection will mean a slightly
    lower resistance, and therefore a lower temp
2022-10-29 Redid vias and moved reference silk
2022-10-29 Move Testpoints that are very close to a LED
2023-01-23 Remove components from mounting frame lines
2023-02-07 Reduce board size
    0.5mm have been removed from all sides
2023-02-11 Move connector up
    To avoid connecting the PCBs wrong both lower pin lists
    have been moved up 50 mil.
2023-02-11 Change LCSC partnumbers for LEDS and NM for testpoints
2023-03-11 Fix small changed for rev2
2023-04-14 Final fixes before production
