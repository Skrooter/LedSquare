File: leds.kicad_sch (KiCad schematic)
At the start: 58 parts

Commit message: Add GND testpoints
Each other testpoint now has its own ground reference

fix #6
Parts:
- added TP307, TP308, TP309, TP310, TP311: TestPoint, TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded, symbol Connector:TestPoint
Connections:
- net GND: now also TP307.1, TP308.1, TP309.1, TP310.1, TP311.1
Changed lines of the file:
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@@
   (junction (at 56.515 124.46) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 43.18 187.96) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 33.02 187.96) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 53.34 187.96) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 56.515 33.02) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 173.355 33.02) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 63.5 187.96) (diameter 0) (color 0 0 0 0)
+  )
   (wire (pts (xy 84.455 63.5) (xy 76.835 63.5))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 33.02 187.96) (xy 22.86 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 153.035 124.46) (xy 145.415 124.46))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 43.18 187.96) (xy 33.02 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 71.12 190.5) (xy 71.12 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 33.02 187.96) (xy 33.02 185.42))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 63.5 187.96) (xy 63.5 185.42))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 168.275 154.94) (xy 170.815 154.94))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 71.12 187.96) (xy 63.5 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 145.415 93.98) (xy 153.035 93.98))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 22.86 187.96) (xy 22.86 185.42))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 56.515 124.46) (xy 61.595 124.46))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (polyline (pts (xy 81.28 198.12) (xy 81.28 177.8))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (polyline (pts (xy 12.7 177.8) (xy 81.28 177.8))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 99.695 93.98) (xy 107.315 93.98))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 53.34 187.96) (xy 43.18 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 130.175 124.46) (xy 122.555 124.46))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 63.5 187.96) (xy 53.34 187.96))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 173.355 93.98) (xy 173.355 124.46))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
   )
   (wire (pts (xy 76.835 93.98) (xy 84.455 93.98))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 43.18 187.96) (xy 43.18 185.42))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 53.34 187.96) (xy 53.34 185.42))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (pin "1")
   )
+  (symbol (lib_id "Connector:TestPoint") (at 33.02 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "TP308" (id 0) (at 31.623 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 34.417 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 38.1 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 38.1 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 33.02 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:C") (at 251.46 91.44 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
     )
     (property "Datasheet" "" (id 3) (at 217.17 95.25 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "Connector:TestPoint") (at 63.5 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "TP311" (id 0) (at 62.103 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 64.897 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 68.58 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 68.58 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 63.5 185.42 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Datasheet" "" (id 3) (at 69.215 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "power:GND") (at 71.12 190.5 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR0402" (id 0) (at 71.12 196.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 71.247 194.8942 0))
+    (property "Footprint" "" (id 2) (at 71.12 190.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 71.12 190.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "Connector:TestPoint") (at 22.86 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "TP307" (id 0) (at 21.463 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 24.257 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 27.94 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 27.94 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 22.86 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "LED:WS2812B") (at 114.935 154.94 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "1")
   )
+  (symbol (lib_id "Connector:TestPoint") (at 53.34 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "TP310" (id 0) (at 51.943 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 54.737 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 58.42 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 58.42 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 53.34 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:+5V") (at 217.17 87.63 0) (unit 1)
     (in_bom yes) (on_board yes)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+  )
+  (symbol (lib_id "Connector:TestPoint") (at 43.18 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "TP309" (id 0) (at 41.783 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 44.577 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 48.26 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 48.26 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 43.18 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Add 12V testpoint
fix #3
Parts:
- added TP312: TestPoint, TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded, symbol Connector:TestPoint
Connections:
- net GND: now also TP312.1
Changed lines of the file:
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@@
 (kicad_sch (version 20211123) (generator eeschema)
   (paper "A4")
+  (junction (at 73.66 187.96) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 56.515 63.5) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 71.12 190.5) (xy 71.12 187.96))
+  (wire (pts (xy 73.66 190.5) (xy 73.66 187.96))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 71.12 187.96) (xy 63.5 187.96))
+  (wire (pts (xy 63.5 187.96) (xy 73.66 187.96))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
   )
   (wire (pts (xy 122.555 154.94) (xy 130.175 154.94))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 73.66 187.96) (xy 73.66 185.42))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (pin "1")
   )
-  (symbol (lib_id "power:GND") (at 71.12 190.5 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR0402" (id 0) (at 71.12 196.85 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (id 1) (at 71.247 194.8942 0))
-    (property "Footprint" "" (id 2) (at 71.12 190.5 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 71.12 190.5 0)
+  (symbol (lib_id "power:GND") (at 73.66 190.5 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR0402" (id 0) (at 73.66 196.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 73.787 194.8942 0))
+    (property "Footprint" "" (id 2) (at 73.66 190.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 73.66 190.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+  )
+  (symbol (lib_id "Connector:TestPoint") (at 73.66 185.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "TP312" (id 0) (at 72.263 181.6842 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (id 1) (at 75.057 183.8202 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 78.74 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 78.74 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 73.66 185.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Add some more requirements
Other:
- note added: "GND reference Test Points"
- note added: "Reqs: Series resistor on data in. Pull up on data in do avoid glitches when unconnected and to be able to use STM32 with open drain pin pin config"
Changed lines of the file:
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@@
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (polyline (pts (xy 81.28 177.8) (xy 176.53 177.8))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (text "Reqs:\nSeries resistor on data in.\nPull up on data in do avoid glitches when unconnected \n   and to be able to use STM32 with open drain pin\n   pin config"
+    (at 82.55 189.23 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "GND reference Test Points" (at 12.7 196.85 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "DataInFiltered" (at 60.96 33.02 270)

Commit message: Move Testpoints that are very close to a LED
Connections:
- net DataIn: now also TP301.1
- net DataInFiltered: no longer TP301.1
Other:
- moved on the sheet: TP301
Changed lines of the file:
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@@
   (junction (at 173.355 93.98) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 43.18 33.02) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 170.815 154.94) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 39.37 33.02) (xy 46.99 33.02))
+  (wire (pts (xy 39.37 33.02) (xy 43.18 33.02))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
   )
   (wire (pts (xy 107.315 124.46) (xy 99.695 124.46))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 43.18 33.02) (xy 46.99 33.02))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (pin "4")
   )
-  (symbol (lib_id "Connector:TestPoint") (at 56.515 33.02 180) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "TP301" (id 0) (at 58.42 38.1 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "TestPoint" (id 1) (at 55.118 34.6198 0)
+  (symbol (lib_id "Connector:TestPoint") (at 43.18 33.02 180) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "TP301" (id 0) (at 45.085 38.1 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "TestPoint" (id 1) (at 41.783 34.6198 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 51.435 33.02 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 51.435 33.02 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C238122" (id 4) (at 56.515 33.02 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded" (id 2) (at 38.1 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 38.1 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C238122" (id 4) (at 43.18 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
