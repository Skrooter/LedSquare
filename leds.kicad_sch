File: leds.kicad_sch (KiCad schematic)
At the start: 58 parts

Commit message: Change LED to one in JLC stock
Parts:
- D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D3, D4, D5, D6, D7, D8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: LCSC C2920042 -> C2874885
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 114.935 124.46 0)
+    (property "LCSC" "C2874885" (id 4) (at 114.935 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 92.075 154.94 0)
+    (property "LCSC" "C2874885" (id 4) (at 92.075 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 160.655 154.94 0)
+    (property "LCSC" "C2874885" (id 4) (at 160.655 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 92.075 63.5 0)
+    (property "LCSC" "C2874885" (id 4) (at 92.075 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 69.215 154.94 0)
+    (property "LCSC" "C2874885" (id 4) (at 69.215 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 69.215 63.5 0)
+    (property "LCSC" "C2874885" (id 4) (at 69.215 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 160.655 63.5 0)
+    (property "LCSC" "C2874885" (id 4) (at 160.655 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 114.935 33.02 0)
+    (property "LCSC" "C2874885" (id 4) (at 114.935 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 114.935 63.5 0)
+    (property "LCSC" "C2874885" (id 4) (at 114.935 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 160.655 124.46 0)
+    (property "LCSC" "C2874885" (id 4) (at 160.655 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 69.215 124.46 0)
+    (property "LCSC" "C2874885" (id 4) (at 69.215 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 137.795 93.98 0)
+    (property "LCSC" "C2874885" (id 4) (at 137.795 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 160.655 33.02 0)
+    (property "LCSC" "C2874885" (id 4) (at 160.655 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 114.935 154.94 0)
+    (property "LCSC" "C2874885" (id 4) (at 114.935 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 137.795 33.02 0)
+    (property "LCSC" "C2874885" (id 4) (at 137.795 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 69.215 93.98 0)
+    (property "LCSC" "C2874885" (id 4) (at 69.215 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 137.795 124.46 0)
+    (property "LCSC" "C2874885" (id 4) (at 137.795 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 69.215 33.02 0)
+    (property "LCSC" "C2874885" (id 4) (at 69.215 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 92.075 124.46 0)
+    (property "LCSC" "C2874885" (id 4) (at 92.075 124.46 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 92.075 93.98 0)
+    (property "LCSC" "C2874885" (id 4) (at 92.075 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 160.655 93.98 0)
+    (property "LCSC" "C2874885" (id 4) (at 160.655 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 92.075 33.02 0)
+    (property "LCSC" "C2874885" (id 4) (at 92.075 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 137.795 154.94 0)
+    (property "LCSC" "C2874885" (id 4) (at 137.795 154.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 114.935 93.98 0)
+    (property "LCSC" "C2874885" (id 4) (at 114.935 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
-    (property "LCSC" "C2920042" (id 4) (at 137.795 63.5 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "LCSC" "C2874885" (id 4) (at 137.795 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Move 5v TP closer to DC/DC and added more TP
fix #4
Parts:
- renumbered C1 to C301, C2 to C302, C3 to C303, C4 to C304, C5 to C305, C6 to C306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
